FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SPLASH_IMAGE = "logo.png"
